# Keil uVision project picoC.uvproj, settings and files
target picoC-STM32 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: picoC
  c flags: Optim=2 OneElfS=1
  c define: EMBEDDED_HOST USE_STDPERIPH_DRIVER STM32F10X_HD
  c include: .\STM32;.\STM32\STM32F10x_StdPeriph_Driver\inc;.\STM32\CMSIS\Device\ST\STM32F10x\Include;.\STM32\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ./: main.c library_common.c platform_common.c hardware_common.h
    ../: picoc.c platform.c debug.c clibrary.c type.c parse.c expression.c heap.c include.c lex.c table.c variable.c
  group cstdlib
    ../cstdlib/: ctype.c errno.c math.c stdbool.c stdio.c stdlib.c string.c time.c
  group STM32
    ./STM32/: startup_stm32f10x_hd.s system_stm32f10x.c STM32F10x_conf.h platform_stm32.c library_stm32.c hardware.h
  group STM32_StdLib
    ./STM32/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group EFM32
    ./EFM32/Device/EnergyMicro/EFM32GG/Source/ARM/: startup_efm32gg.s
    ./EFM32/Device/EnergyMicro/EFM32GG/Source/: system_efm32gg.c
    ./EFM32/: platform_efm32.c library_efm32.c hardware.h segmentlcd.c segmentlcd.h
  group EFM32_StdLib
    ./EFM32/emlib/src/: em_cmu.c em_gpio.c em_usart.c em_system.c em_emu.c em_lcd.c
target picoC-EFM32 (ARM-ADS)
  device: EFM32GG995F1024 Energy Micro
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: uC +hex
  AfterMake: D:\Keil\ARM\ARMCC\bin\fromelf.exe --bin --output=build\EFM32\uC.bin build\EFM32\uC.axf
  c flags: Optim=2 OneElfS=1
  c define: EMBEDDED_HOST EFM32GG990F1024
  c misc: --c99
  c include: .\EFM32;.\EFM32\emlib\inc;.\EFM32\Device\EnergyMicro\EFM32GG\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
